# Keil uVision project Hatrix.uvprojx, settings and files
target Hatrix (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Hatrix +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/Include;../Core/Inc;../User/Hatrix;../User/Application;../User/Protocol;../User/Algorithm;../User/Library;../User/Peripheral;../User/Utility;../User/System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hatrix
    ../User/Hatrix/: init_ctrl.c callback_ctrl.c task_ctrl.c
  group Application
    ../User/Application/: app_ins.c app_motor_test.c
  group Protocol
    ../User/Protocol/: protocol_motor.c
  group Algorithm
    ../User/Algorithm/: alg_pid.c alg_kf.c alg_qekf.c
  group Library
    ../Drivers/CMSIS/DSP/Include/: arm_cortexM4lf_math.lib
    ../User/Library/: lib_math.c lib_filter.c lib_buff.c lib_crc.c
  group Peripheral
    ../User/Peripheral/: periph_led.c periph_key.c periph_buzzer.c periph_servo.c periph_motor_can.c periph_bmi088.c
  group Utility
    ../User/Utility/: util_gpio.c util_pwm.c util_spi.c util_can.c
  group System
    ../User/System/: sys_dwt.c
software components: CMSIS:CORE 5.6.0
